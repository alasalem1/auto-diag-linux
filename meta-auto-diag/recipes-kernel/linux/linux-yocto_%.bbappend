FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://autodiag-can.cfg"
